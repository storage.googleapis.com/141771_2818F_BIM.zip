Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-06T23:17:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 06 23:17:31 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{465DF277-DDA3-4589-8C8A-65D092F99FA6}\ifc * Database version: 5507 * Database creation date: Mon Aug 06 23:17:30 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 06 23:17:31 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 06 23:17:31 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 2818F Bidet faucet, 2818F:2818F Bidet faucet:312974
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 125 mm; NominalHeight: 164 mm; NominalWidth: 50 mm; Projection: 115 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 2818F; ConvergoRefNr: 0087-1809-0015-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_20_87_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_30_96_07; Version: 1; VersionDate: 27/07/2018
Type - Green Building Properties(Type) - Backflow Prevention EN1717: HC; EAN Number: 6414150058295; EN Standard: EN 817; Noise Class: I (ISO 3822); NRF Number: 4201439; VVS Number: 705272504
Type - Identity Data(Type) - Class: Single lever; Group: Bidet faucets; Manufacturer: Oras; Market: INT;EST;LVA;LTU;NOR;RUS;UKR;POL; Model: 2818F Bidet faucet; Name_en: 2818F Bidet faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2818F; Product Datasheet: https://www.oras.com/datasheet/2818F/en; Product Family: Oras Cubista; Product URL: https://www.oras.com/en/products/oras/product/2818F; Type Name: 2818F Bidet faucet; Usage Group: Households
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Aerator: Swivel aerator; Connection Size: G3/8; Extensions: Rapid pop-up waste; Flow Rate At 300kPa: 0.00565035 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/109791_PDM_943013_F_(943013-01-16).pdf; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 1 mounting hole; Pipes: Flexible inlet pipe(s); Pressure Loss With Flow 01ls: 115000 Pa; Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP2810/; Spout Type: Fixed spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2818F; Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2818F; Name: 2818F Bidet faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x125x164 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2818F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2818F Bidet faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0360495 m2; Volume: 0.00102971 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 2818F: 2818F Bidet faucet; Family and Type: 2818F: 2818F Bidet faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2818F: 2818F Bidet faucet; Type Id: 2818F: 2818F Bidet faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
